** vco.cir **
*
* For testing vco.mod
*
Vcc cc gnd DC 6V
Vee ee gnd DC -6V
Vin in gnd 0V
Xvco cc ee in out emitter_coupled_oscillator
Rload out gnd 10k
*
.include vco.mod
.control
tran 1E-7 8E-3 1E-7
plot v(out)
*
